<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Maze_Solver_Controller.ewp</path>
  </project>
  <batchBuild />
</workspace>
